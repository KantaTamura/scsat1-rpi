FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-unix-configure-follow-gcc-14-changes.patch"

