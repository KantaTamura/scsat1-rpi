FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-pseudolog.c-follow-gcc-14-changes.patch"

